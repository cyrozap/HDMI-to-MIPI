# Repository cyrozap/HDMI-to-MIPI

File README.md:

# HDMI-to-MIPI

This was meant to be an HDMI to MIPI adapter, which would convert an HDMI input
to a MIPI-DSI output, so that a smartphone/tablet display could be driven by any
device with an HDMI output.

Unfortunately, I never finished this project, and I don't plan to.

That said, if you want to use the desings in this repository, please keep the
following points in mind:

 - The routed PCB design of the [HDMI-to-LH550WF1 adapter](HDMI-to-LH550WF1) is
   not suitable for production for most of the reasons stated in commit
   [1a36764][1a36764]. While some of the issues have been fixed since then, the
   revised design was never completed.
 - I never wrote any firmware for the adapter.
 - I never manufactured any of the PCB designs in this repository, so I have no
   idea if any of them work. Please assume that they don't.

[1a36764]: https://github.com/cyrozap/HDMI-to-MIPI/commit/1a36764ce93b363b307ddc5b0dbcfbc45c0893f7

## KiCad design HDMI-to-LH550WF1/HDMI-to-LH550WF1.kicad_pcb

Parts:
P1: USB_OTG; USB_Mini-B
P2: HDMI; FCI_10029449-111RLF

Connections:
/CLK_N: P2.12 (CLKN); also elsewhere on the board
/CLK_P: P2.10 (CLKP); also elsewhere on the board
/Control/USB_DM: P1.2 (D-); also elsewhere on the board
/Control/USB_DP: P1.3 (D+); also elsewhere on the board
/D0_N: P2.9 (D0N); also elsewhere on the board
/D0_P: P2.7 (D0P); also elsewhere on the board
/D1_N: P2.6 (D1N); also elsewhere on the board
/D1_P: P2.4 (D1P); also elsewhere on the board
/D2_N: P2.3 (D2N); also elsewhere on the board
/D2_P: P2.1 (D2P); also elsewhere on the board
/HDMI_5V: P2.18 (+5V); also elsewhere on the board
/HPD: P2.19 (HPD); also elsewhere on the board
/Power/USB_VBUS: P1.1 (VBUS); also elsewhere on the board
/SCL: P2.15 (SCL); also elsewhere on the board
/SDA: P2.16 (SDA); also elsewhere on the board
GND: P1.5 (GND), P1.6 (Shield), P2.0 (SHIELD), P2.2 (D2S), P2.5 (D1S), P2.8 (D0S), P2.11 (CLKS), P2.17 (GND); also elsewhere on the board

Parts:
C1, C4, C6, C8, C9, C10, C11: 10nF; C_0402
C2, C3, C5, C7, C12, C13, C14: 100nF; C_0402
R1, R3, R5, R6: 47k; R_0402
R2: 100k; R_0402
R4: 10k; R_0402
R7, R9: 1k; R_0402
R8: 2k/1%; R_0402
U1: DSC6101JI2A-048.0000; VLGA-4_2.5x2.0mm
U2: TC358870XBG; VFBGA-80_7x7mm_Pitch0.65mm

Connections:
+1V1: C5.1, C6.1, C11.1, C14.1, U2.B2 (VDD11_HDMI), U2.C10 (VDDC11), U2.G2 (VDD11_HDMI), U2.K6 (VDDC11); also elsewhere on the board
+1V2: C7.1, C8.1, U2.B10 (VDD12_MIPI1), U2.J10 (VDD12_MIPI0); also elsewhere on the board
+1V8: C1.1, C2.1, C10.1, C13.1, R5.1, R6.1, U1.4 (VDD), U2.J7 (VDDIO18); also elsewhere on the board
+3V3: C3.1, C4.1, C9.1, C12.1, R8.2, U2.B1 (VDD33_HDMI), U2.G1 (VDD33_HDMI), U2.H2 (VDDIO33); also elsewhere on the board
/CLK_N: U2.C2 (HDMICN); also elsewhere on the board
/CLK_P: U2.C1 (HDMICP); also elsewhere on the board
/Control/BRIDGE_INT: U2.J3 (INT); also elsewhere on the board
/Control/BRIDGE_RESET_N: U2.K8 (RESETN); also elsewhere on the board
/Control/BRIDGE_SCL: R5.2, U2.K4 (I2C_SCL); also elsewhere on the board
/Control/BRIDGE_SDA: R6.2, U2.K3 (I2C_SDA); also elsewhere on the board
/D0_N: U2.D2 (HDMID0N); also elsewhere on the board
/D0_P: U2.D1 (HDMID0P); also elsewhere on the board
/D1_N: U2.E2 (HDMID1N); also elsewhere on the board
/D1_P: U2.E1 (HDMID1P); also elsewhere on the board
/D2_N: U2.F2 (HDMID2N); also elsewhere on the board
/D2_P: U2.F1 (HDMID2P); also elsewhere on the board
/HDMI-Bridge/REFCLK: U1.3 (OUTPUT), U2.K9 (REFCLK)
/HDMI_5V: R1.2, R2.1, R3.2, R4.2, U2.A4 (HPDI); also elsewhere on the board
/HPD: R7.2; also elsewhere on the board
/LCD-Panel/CLK_N: U2.F9 (CDSI0CN); also elsewhere on the board
/LCD-Panel/CLK_P: U2.F10 (CDSI0CP); also elsewhere on the board
/LCD-Panel/DATA0_N: U2.H9 (CDSI0D0N); also elsewhere on the board
/LCD-Panel/DATA0_P: U2.H10 (CDSI0D0P); also elsewhere on the board
/LCD-Panel/DATA1_N: U2.G9 (CDSI0D1N); also elsewhere on the board
/LCD-Panel/DATA1_P: U2.G10 (CDSI0D1P); also elsewhere on the board
/LCD-Panel/DATA2_N: U2.E9 (CDSI0D2N); also elsewhere on the board
/LCD-Panel/DATA2_P: U2.E10 (CDSI0D2P); also elsewhere on the board
/LCD-Panel/DATA3_N: U2.D9 (CDSI0D3N); also elsewhere on the board
/LCD-Panel/DATA3_P: U2.D10 (CDSI0D3P); also elsewhere on the board
/SCL: R1.1, U2.A3 (DDC_SCL); also elsewhere on the board
/SDA: R3.1, U2.B3 (DDC_SDA); also elsewhere on the board
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, C10.2, C11.2, C12.2, C13.2, C14.2, R2.2, R9.2, U1.2 (GND), U2.A10 (VSS), U2.C9 (VSS), U2.D4 (VSS), U2.D5 (VSS), U2.D6 (VSS), U2.D7 (VSS), U2.E4 (VSS), U2.E5 (VSS), U2.E6 (VSS), U2.E7 (VSS), U2.F4 (VSS), U2.F5 (VSS), U2.F6 (VSS), U2.F7 (VSS), U2.G4 (VSS), U2.G6 (IR), U2.G7 (VSS), U2.H1 (VSS), U2.K10 (VSS); also elsewhere on the board
unnamed: R4.1, U2.A2 (CEC)
unnamed: R7.1, U2.B4 (HPDO)
unnamed: R8.1, U2.A1 (REXT)
unnamed: R9.1, U2.G5 (TEST)

Parts:
C15, C18, C21, C22: 4.7uF; C_0603
C16: 1uF; C_0603
C17: 220nF; C_0402
C19: 2.2uF; C_0603
C20: 0.47uF; C_0603
D1: MBR0540T1; SOD-123
L1: 4.7uH; R_0805
L2: 10uH; Inductor_Taiyo-Yuden_MD-3030
P3: LH550WF1; GB042-30S
R10: 10R/1%; R_0402
U3: TPS65132A0YFF; DSBGA-15_1.5x2.1mm_Pitch0.4mm
U4: TPS61161; WSON-6_2x2mm_Pitch0.65mm

Connections:
+1V8: P3.26 (IOVCC); also elsewhere on the board
+5V: C15.1, C16.1, L1.1, L2.1, U3.A1 (ENN), U3.B1 (ENP), U3.C1 (VIN), U4.6 (VIN); also elsewhere on the board
/Control/PANEL_RESET: P3.23 (RESET); also elsewhere on the board
/LCD-Panel/CLK_N: P3.11 (CLKN); also elsewhere on the board
/LCD-Panel/CLK_P: P3.10 (CLKP); also elsewhere on the board
/LCD-Panel/DATA0_N: P3.17 (DATA0N); also elsewhere on the board
/LCD-Panel/DATA0_P: P3.18 (DATA0P); also elsewhere on the board
/LCD-Panel/DATA1_N: P3.20 (DATA1N); also elsewhere on the board
/LCD-Panel/DATA1_P: P3.21 (DATA1P); also elsewhere on the board
/LCD-Panel/DATA2_N: P3.8 (DATA2N); also elsewhere on the board
/LCD-Panel/DATA2_P: P3.7 (DATA2P); also elsewhere on the board
/LCD-Panel/DATA3_N: P3.14 (DATA3N); also elsewhere on the board
/LCD-Panel/DATA3_P: P3.13 (DATA3P); also elsewhere on the board
/LCD-Panel/LED_A: C20.1, D1.1 (K), P3.2 (LED_A)
/LCD-Panel/LED_C: P3.28 (LED_C2), P3.29 (LED_C1), R10.1, U4.1 (FB)
/LCD-Panel/LED_PWM: P3.25 (LED_PWM), U4.5 (CTRL)
/LCD-Panel/VSN: C22.1, P3.5 (VSN), U3.A2 (OUTN)
/LCD-Panel/VSP: C21.1, P3.4 (VSP), U3.E3 (OUTP)
GND: C15.2, C16.2, C17.2, C18.1, C20.2, C21.2, C22.2, P3.1 (GND), P3.3 (GND), P3.6 (GND), P3.9 (GND), P3.12 (GND), P3.15 (GND), P3.19 (GND), P3.22 (GND), P3.27 (GND), P3.30 (GND), R10.2, U3.B2 (SCL), U3.B3 (PGND), U3.C2 (SDA), U3.D2 (AGND), U3.E1 (PGND), U4.3 (GND); also elsewhere on the board
unnamed: C17.1, U4.2 (COMP)
unnamed: C18.2, U3.D3 (REG), U3.E2 (REG)
unnamed: C19.1, U3.C3 (CFLY1)
unnamed: C19.2, U3.A3 (CFLY2)
unnamed: D1.2 (A), L2.2, U4.4 (SW)
unnamed: L1.2, U3.D1 (SW)

Notes on the sheet:
Inductor L2 is Murata LQH3NPN100NM0.
Inductor is Murata LQM21PN4R7MGR.

Schematic: Power.sch

Parts:
C23, C24, C25: 1uF; C_0603
C26, C29: 10uF; SMD-1206_Pol
C27, C33: 10nF; C_0402
C28: 100nF; C_0402
C30: 22uF; SMD-1206_Pol
C31, C32, C34: 1uF/X5R; C_0603
D2, D3, D4, D5: Led_Small; LED_0603
JP1, JP3, JP4, JP5, JP6, JP11: Jumper_NC_Small; Pin_Header_Straight_1x02
JP2, JP7, JP8, JP9, JP10, JP12: Jumper_NO_Small; Pin_Header_Straight_1x02
L3: BLM18PG221SN1D; R_0603
Q1, Q2, Q3: 2N2222; SOT-23
R11, R12, R13: 10k; R_0402
R14: 10.2k/1%; R_0402
R15: 23.2k/1%; R_0402
R16, R20, R21: 100R; R_0402
R17, R22, R23: 100k; R_0402
R18, R19, R24, R25: 1k; R_0402
U5: AZ1117H-3.3TRE1; SOT-223
U6: AP2127K-1.8TRG1; SOT-23-5
U7: AP2127K-1.2TRG1; SOT-23-5
U8: AP2127K-ADJTRG1; SOT-23-5

Connections:
+1V1: JP11.2, JP12.1, R21.1; also elsewhere on the board
+1V2: JP6.2, JP10.1, R20.1; also elsewhere on the board
+1V8: JP5.2, JP9.1, R16.1; also elsewhere on the board
+3V3: C23.1, C24.1, C25.1, D2.2 (A), D3.2 (A), D4.2 (A), D5.2 (A), JP4.2, JP8.1, R11.1, R12.1, R13.1, U6.1 (VIN), U7.1 (VIN), U8.1 (VIN); also elsewhere on the board
+5V: C26.1, JP3.2, JP7.1, U5.3 (VI); also elsewhere on the board
/Power/USB_VBUS: JP1.1; also elsewhere on the board
GND: C23.2, C24.2, C25.2, C26.2, C27.2, C28.2, C29.2, C30.2, C31.2, C32.2, C34.2, JP2.2, JP7.2, JP8.2, JP9.2, JP10.2, JP12.2, Q1.2, Q2.2, Q3.2, R15.2, R17.2, R18.2, R22.2, R23.2, U5.1 (GND/ADJ), U6.2 (GND), U7.2 (GND), U8.2 (GND); also elsewhere on the board
unnamed: C27.1, JP1.2, JP2.1, L3.1
unnamed: C28.1, C29.1, JP3.1, L3.2
unnamed: C30.1, JP4.1, U5.2 (VO), U5.4 (VO)
unnamed: C31.1, JP5.1, U6.5 (VOUT)
unnamed: C32.1, JP6.1, U7.5 (VOUT)
unnamed: C33.1, C34.1, JP11.1, R14.1, U8.5 (VOUT)
unnamed: C33.2, R14.2, R15.1, U8.4 (NC/ADJ)
unnamed: D2.1 (K), R18.1
unnamed: D3.1 (K), R19.1
unnamed: D4.1 (K), R24.1
unnamed: D5.1 (K), R25.1
unnamed: Q1.1, R16.2, R17.1
unnamed: Q1.3, R19.2
unnamed: Q2.1, R20.2, R22.1
unnamed: Q2.3, R24.2
unnamed: Q3.1, R21.2, R23.1
unnamed: Q3.3, R25.2
unnamed: R11.2, U6.3 (~SHDN~)
unnamed: R12.2, U7.3 (~SHDN~)
unnamed: R13.2, U8.3 (~SHDN~)

Notes on the sheet:
Transistors are MMBT2222LT1G.
VOUT=0.8*(1+R1/R2) R1=R2*(VOUT/0.8-1) R1=R2*0.4375 0.8*(1+10.2k/23.2k)=1.1517V

Parts:
C35, C39, C41, C47, C49: 10nF; C_0402
C36, C40, C42, C43, C44, C45, C48: 100nF; C_0402
C37, C38: 18pF; C_0402
C46: 4.7uF; C_0603
C50: 1uF; C_0603
D6, D7, D8, D9, D10, D11, D12, D13: Green; LED_0603
JP13: Jumper_NO_Small; Pin_Header_Straight_1x02
P4: CONN_02X10; IDC_Header_Straight_20pins
P5: CONN_01X03; Pin_Header_Straight_1x03
R26, R27, R29, R32: 47k; R_0402
R28, R31: 10k; R_0402
R30, R33, R34, R35, R36, R37, R38, R39, R40: 1k; R_0402
U9, U10: FXMA2104UMX; UMLP-12_1.8x1.8mm_Pitch0.4mm
U11: STM32F103C8Tx; LQFP-48_7x7mm_Pitch0.5mm
Y1: 8MHz; Crystal_HC49-SD_SMD

Connections:
+1V8: C39.1, C40.1, C47.1, C48.1; also elsewhere on the board
+3V3: C35.1, C36.1, C41.1, C42.1, C43.1, C44.1, C45.1, C46.1, C49.1, C50.1, P4.1, R26.1, R27.1, R29.1, R30.1, R31.1, R32.1, U11.9 (VDDA), U11.24 (VDD), U11.36 (VDD), U11.48 (VDD); also elsewhere on the board
/Control/BRIDGE_INT: U9.9 (B3); also elsewhere on the board
/Control/BRIDGE_RESET_N: U9.10 (B2); also elsewhere on the board
/Control/BRIDGE_SCL: U9.11 (B1); also elsewhere on the board
/Control/BRIDGE_SDA: U9.12 (B0); also elsewhere on the board
/Control/BR_INT: U9.6 (A3), U11.18 (PB0/ADC1_IN8/ADC2_IN8/TIM1_CH2N/TIM3_CH3)
/Control/BR_RST_N: U9.5 (A2), U11.19 (PB1/ADC1_IN9/ADC2_IN9/TIM1_CH3N/TIM3_CH4)
/Control/LED0: D6.2 (A), U11.10 (ADC1_IN0/ADC2_IN0/SYS_WKUP/TIM2_CH1/TIM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)
/Control/LED1: D7.2 (A), U11.11 (ADC1_IN1/ADC2_IN1/TIM2_CH2/USART2_RTS/P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)
/Control/LED2: D8.2 (A), U11.12 (ADC1_IN2/ADC2_IN2/TIM2_CH3/USART2_TX/PA2)
/Control/LED3: D9.2 (A), U11.13 (ADC1_IN3/ADC2_IN3/TIM2_CH4/USART2_RX/PA3)
/Control/LED4: D10.2 (A), U11.14 (ADC1_IN4/ADC2_IN4/SPI1_NSS/USART2_CK/PA4)
/Control/LED5: D11.2 (A), U11.15 (ADC1_IN5/ADC2_IN5/SPI1_SCK/PA5)
/Control/LED6: D12.2 (A), U11.16 (ADC1_IN6/ADC2_IN6/SPI1_MISO/TIM1_BKIN/T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)
/Control/LED7: D13.2 (A), U11.17 (ADC1_IN7/ADC2_IN7/SPI1_MOSI/TIM1_CH1N/T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)
/Control/PANEL_RESET: U10.12 (B0); also elsewhere on the board
/Control/PNL_RST: U10.3 (A0), U11.46 (PB9/CAN_TX/I2C1_SDA/TIM4_CH4)
/Control/RX: P5.2, U11.31 (TIM1_CH3/USART1_RX/PA10)
/Control/SCL: R27.2, U9.4 (A1), U11.21 (PB10/I2C2_SCL/TIM2_CH3/USART3_TX)
/Control/SDA: R29.2, U9.3 (A0), U11.22 (PB11/ADC1_EXTI11/ADC2_EXTI11/I2C2_SDA/T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)
/Control/TCK: P4.9, U11.37 (SYS_JTCK-SWCLK/PA14)
/Control/TDI: P4.5, U11.38 (ADC1_EXTI15/ADC2_EXTI15/SPI1_NSS/SYS_JT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)
/Control/TDO: P4.13, U11.39 (PB3/SPI1_SCK/SYS_JTDO-TRACESWO/TIM2_CH2)
/Control/TMS: P4.7, U11.34 (SYS_JTMS-SWDIO/PA13)
/Control/TX: P5.1, U11.30 (TIM1_CH2/USART1_TX/PA9)
/Control/USB_DM: U11.32 (ADC1_EXTI11/ADC2_EXTI11/CAN_RX/TIM1_CH4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); also elsewhere on the board
/Control/USB_DP: U11.33 (CAN_TX/TIM1_ETR/USART1_RTS/USB_DP/PA12); also elsewhere on the board
/Control/~SRST~: P4.15, R31.2, U11.7 (NRST)
/Control/~TRST~: P4.3, U11.40 (PB4/SPI1_MISO/SYS_NJTRST/TIM3_CH1)
GND: C37.1, C38.2, C43.2, C44.2, C45.2, C46.2, C49.2, C50.2, P4.4, P4.6, P4.8, P4.10, P4.12, P4.14, P4.16, P4.18, P4.20, P5.3, R28.2, R33.2, R34.2, R35.2, R36.2, R37.2, R38.2, R39.2, R40.2, U9.7 (GND), U10.7 (GND), U11.8 (VSSA), U11.23 (VSS), U11.35 (VSS), U11.47 (VSS); also elsewhere on the board
unnamed: C35.2, C36.2, U9.2 (VCCA)
unnamed: C37.2, U11.5 (PD0/RCC_OSC_IN), Y1.2
unnamed: C38.1, U11.6 (PD1/RCC_OSC_OUT), Y1.1
unnamed: C39.2, C40.2, U9.1 (VCCB)
unnamed: C41.2, C42.2, U10.2 (VCCA)
unnamed: C47.2, C48.2, U10.1 (VCCB)
unnamed: D6.1 (K), R33.1
unnamed: D7.1 (K), R34.1
unnamed: D8.1 (K), R35.1
unnamed: D9.1 (K), R36.1
unnamed: D10.1 (K), R37.1
unnamed: D11.1 (K), R38.1
unnamed: D12.1 (K), R39.1
unnamed: D13.1 (K), R40.1
unnamed: JP13.1, R28.1, U11.44 (BOOT0)
unnamed: JP13.2, R30.2
unnamed: R26.2, U9.8 (OE)
unnamed: R32.2, U10.8 (OE)

Notes on the sheet:
Crystal is ABLS-8.000MHZ-B4-T.
4.7uF cap must be connected to VDD3 (pin 48). 10nF and 1uF caps are connected to VDDA (pin 9).

Board: 4 copper layers, 71.8 x 61.0 mm, 139 parts (1 on the bottom side), 111 nets.

## KiCad design SSD2828QN4-breakout/SSD2828QN4-breakout.kicad_pcb

Board: 2 copper layers, 18 parts (0 on the bottom side), 58 nets.

Parts:
C1, C2: 20pF; C_0603
P1: CONN_01X30; TE_3-1734592-0
P2, P4, P5, P8, P9, P10: CONN_01X02; Pin_Header_Straight_1x02
P3: CONN_01X05; Pin_Header_Straight_1x05
P6, P11: CONN_01X03; Pin_Header_Straight_1x03
P7: CONN_02X10; Pin_Header_Straight_2x10
R1, R2, R3: 10K; R_0603
U1: SSD2828QN4; QFN-68-1EP_8x8mm_Pitch0.4mm
Y1: 24MHz; Crystal_HC49-SD_SMD

Connections:
+1V2: P5.1, U1.15, U1.31, U1.60, U1.66
+3V3: P4.1, U1.16, U1.33, U1.64, U1.68
/CLK1: C1.1, U1.63, Y1.1
/CLK2: C2.2, U1.62, Y1.2
/CLK_N: P7.13, U1.8
/CLK_P: P7.14, U1.7
/CSN: P3.4, U1.59
/D0_N: P7.19, U1.2
/D0_P: P7.20, U1.1
/D1_N: P7.16, U1.5
/D1_P: P7.17, U1.4
/D2_N: P7.10, U1.11
/D2_P: P7.11, U1.10
/D3_N: P7.7, U1.14
/D3_P: P7.8, U1.13
/DATA0: P1.6, U1.35
/DATA1: P1.7, U1.36
/DATA2: P1.8, U1.37
/DATA3: P1.9, U1.38
/DATA4: P1.10, U1.39
/DATA5: P1.11, U1.40
/DATA6: P1.12, U1.41
/DATA7: P1.13, U1.42
/DATA8: P1.14, U1.43
/DATA9: P1.15, U1.44
/DATA10: P1.16, U1.45
/DATA11: P1.17, U1.46
/DATA12: P1.18, U1.47
/DATA13: P1.19, U1.48
/DATA14: P1.20, U1.49
/DATA15: P1.21, U1.50
/DATA16: P1.22, U1.51
/DATA17: P1.23, U1.52
/DATA18: P1.24, U1.53
/DATA19: P1.25, U1.54
/DATA20: P1.26, U1.55
/DATA21: P1.27, U1.56
/DATA22: P1.28, U1.57
/DATA23: P1.29, U1.58
/DEN: P1.2, U1.28
/HSYNC: P1.3, U1.29
/IOVCC: P7.3, P9.1
/LED_A: P7.1, P10.1
/MISO: P3.2, U1.23
/MOSI: P3.1, U1.24
/PCLK: P1.4, U1.30
/RESET: P6.2, U1.22
/SCK: P3.3, U1.25
/SHUT: P6.1, U1.27
/VCC: P7.2, P8.1
/VSN: P7.6, P11.3
/VSP: P7.5, P11.1
/VSYNC: P1.5, U1.34
GND: C1.2, C2.1, P1.1, P1.30, P2.2, P3.5, P4.2, P5.2, P6.3, P7.9, P7.12, P7.15, P7.18, P8.2, P9.2, P10.2, P11.2, R1.2, R2.2, R3.2, U1.3, U1.6, U1.9, U1.12, U1.32, U1.65, U1.67
unnamed: P2.1, U1.61
unnamed: R1.1, U1.18
unnamed: R2.1, U1.17
unnamed: R3.1, U1.26

## Commit log

2015-11-17 Removed unused cache library entry
2015-11-30 Added TFP403 component
2015-11-30 Added .gitignore
2015-11-30 Added TFP403 breakout project
2015-11-30 Added documentation for the TFP403
2015-12-17 Filled-in the TFP403 component diagram
2015-12-18 Added SSD2828QN4 schematic symbol
2016-01-19 Added SSD2828QN4 breakout project
2016-02-01 Added a license (CERN OHL v1.2)
2016-02-01 Added backup files to gitignore
2016-02-17 Changed GB042-30S footprint value to match the footprint name
2016-04-03 Added SSD2828QN4 breakout schematic
2016-04-03 Removed unused libraries
2016-04-03 Added SPI and SHUT/RESET connectors
2016-05-13 Added a footprint filter for the SSD2828QN4
2016-05-29 Added WIP SSD2828QN4 breakout PCB
2016-05-29 Added WIP TFP403 breakout schematic
2016-05-29 Associated components with footprints in the SSD2828QN4 breakout
2016-05-29 Added SSD2828QN4 footprint
2016-05-29 Added 30-pin FFC connector footprint
2016-07-12 Moved component and module libraries into their own repository
    The new repo is at cyrozap/KiCad.
2016-07-12 Added other backup files to gitignore
2016-07-12 Updated library to include its license
2016-07-12 Added fp-lib-table for SSD2828QN4-breakout
2016-07-16 Added TC358870XBG from library
2016-11-24 Updated library and replaced SSD2828QN4 footprint
2016-11-25 Updated library with unified TC358870XBG module
2016-11-25 Updated library to move REXT on TC358870XBG
2016-12-01 Added I2C level translator from library
2016-12-02 Added AP2127K from library
2016-12-02 Updated library to include an HDMI connector
2016-12-02 Fixed HDMI symbol in library
2016-12-02 Added initial HDMI-to-LH550WF1 project with schematic draft
2016-12-03 Annotated schematic and associated footprints
2016-12-06 Renamed some nets to enable differential routing
2016-12-06 Reversed the order of the level-translated pins for easier routing
2016-12-06 C46 should be 0603
2016-12-06 Removed LED8
2016-12-07 Forgot to swap these pins
    See commit 4c4bb9bc006722755480921caf0f6e64ff95cf8d
2016-12-08 Added routed PCB
    I'm adding this to the repo because I spent a lot of time on it and it
    helped me get a good idea for how much this board will cost. However, it
    is NOT SUITABLE FOR PRODUCTION because:
    - Every trace is 5 mils wide, even power traces, and I'm not sure that
    they will be wide enough for the current drawn.
    - The STM32, its crystal, and its programming header take up an
2017-04-20 Fixed issues with STM32 schematic
    - Replaced 20-pin JTAG connector with 10-pin Cortex-M debug connector.
    - Added USB resistors.
    - Switched from 47k I2C pull-ups to 4.7k.
    - Removed all those LEDs.
    - Renamed the JTAG and UART nets for clarity.
    - Switched to a smaller crystal.
2017-04-20 Replace USB connector symbol with updated version
2017-04-20 Fixed issues with power subsystem
    - Removed extra power LEDs.
    - Switched to 0402 1uF capacitors.
    - Power LED is now 0805 instead of 0603.
    - Removed jumpers for current/voltage measurements to save space.
2017-04-20 Fixed issues in LCD panel sheet
    - Replaced inductor values with part numbers.
    - Swapped one 0603 cap for an 0402 one.
2017-04-21 Updated library to add 10-pin Cortex-M debug connector
2017-04-21 Assigned debug connector footprint
2017-04-22 Updated Cortex-M debug connector
2017-11-17 Added PCB backup file to .gitignore
2017-11-17 Added HDMI-to-LH550WF1 symbol library cache
2017-11-17 Added test points to LCD-Panel and Power sheets
2017-11-17 Update library with VFBGA-80 and HDMI connector courtyards
2017-11-17 Assigned test point footprints
2023-03-26 Add Readme with project status
